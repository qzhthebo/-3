# Keil uVision project FlightControl_V1.0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FlightControl_V1.0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\libraries\OnChip\GPIO;.\libraries\System\SysTime;.\libraries\System\Interrupt;.\libraries\OnChip\UART;.\libraries\ToolBox\Buffer;.\App;.\libraries\Toolbox\Serialize;.\libraries\Toolbox\UIDLink;.\libraries\OnChip\TIMER;.\libraries\OnChip\EXIT;.\libraries\OnChip\ADC;.\libraries\OnChip\I2C;.\libraries\OnChip\SPI;.\libraries\OffChip;.\libraries\Toolbox\Math;.\libraries\OffChip\InertialSensor;.\libraries\OffChip\MPU6050;.\libraries\Toolbox\Filter;.\libraries\OffChip\HMC5883l;.\App;.\libraries\OffChip\MS561101;.\libraries\OffChip\OLED;.\libraries\OffChip\SBUS;.\libraries\OffChip\GPS;.\libraries\OffChip\RemoteControl;.\libraries\OffChip\DCBrushLessMotor;.\libraries\OffChip\OPenMV;.\libraries\System\Safety;.\libraries\System\State;.\libraries\OffChip\buzzer;.\libraries\OffChip\IMU_YIS100;.\libraries\LED;.\libraries\sys
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group OnChip
    ./libraries/OnChip/UART/: UART.cpp
    ./libraries/OnChip/GPIO/: GPIO.cpp
    ./libraries/OnChip/TIMER/: Timer.cpp
    ./libraries/OnChip/EXIT/: EXIT.cpp
    ./libraries/OnChip/I2C/: I2C.cpp
    ./libraries/OnChip/SPI/: SPI.cpp
    ./libraries/OnChip/ADC/: ADC.cpp
  group App
    ./: main.cpp
  group System
    ./libraries/System/SysTime/: SysTime.cpp
    ./libraries/System/Interrupt/: Interrupt.cpp
  group Tools
    ./libraries/Toolbox/Serialize/: Serialize.cpp
    ./libraries/Toolbox/UIDLink/: UIDLink.cpp
    ./libraries/Toolbox/Math/: Mahony.cpp Ellipsoid_fitting.cpp
  group OffChip
    ./libraries/OffChip/DCBrushLessMotor/: DCBLMotor.cpp
    ./libraries/OffChip/RemoteControl/: RemoteControl.cpp
    ./libraries/OffChip/SBUS/: SBUS.cpp
    ./libraries/OffChip/MPU6050/: MPU6050.cpp
    ./libraries/OffChip/HMC5883l/: HMC5883l.cpp
    ./libraries/OffChip/MS561101/: MS5611.cpp
    ./libraries/OffChip/OLED/: OLED.cpp
    ./libraries/OffChip/OPenMV/: OpenMV.cpp
    ./libraries/OffChip/buzzer/: buzzer.cpp
    ./libraries/OffChip/IMU_YIS100/: IMU_YIS100.cpp
  group LED
    ./libraries/LED/: led.c
  group SYS
    ./libraries/sys/: sys.c
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
